# Keil uVision project GPIO_examples.uvprojx, settings and files
target Examples (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.3.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: GPIO_examples
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\lpcopen_2_10_keil_iar_ea_devkit_1788\software\CMSIS\CMSIS\Include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group code
    ./: ex1.c ex2.c ex3.c ex4-1.c ex4.c ex5.c ex6.c
software components: Device:Startup 1.0.0
