# Keil uVision project TIMER.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.3.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TIMER
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\Huins\13_cortexm3\lpc175x_6x_cmsis_driver_library_0\lpc175x_6x_cmsis_driver_library\Core\Device\NXP\LPC17xx\Include;..\..\Huins\13_cortexm3\lpc175x_6x_cmsis_driver_library_0\lpc175x_6x_cmsis_driver_library\Drivers\include;..\..\lpcopen_2_10_keil_iar_ea_devkit_1788\software\CMSIS\CMSIS\Include;..\..\Huins\13_cortexm3\lpc175x_6x_cmsis_driver_library_0\lpc175x_6x_cmsis_driver_library\Core\CMSIS\Include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Source Group 1
    ./: timer1.c timer2.c timer3.c
software components: Device:Startup 1.0.0
